## kernel_module/Config.in
```kconfig
config BR2_PACKAGE_KERNEL_MODULE
	bool "kernel_module"
	help
		Kernel module modole for sykom lecture.

		http://example.com/
```
